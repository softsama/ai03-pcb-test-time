# Repository softsama/ai03-pcb-test-time

## KiCad design ai03-pcb-test-time.kicad_pcb

Parts:
C1, C2, C5: 0.1uF; C_0805_2012Metric
C3, C4: 22pF; C_0805_2012Metric
C6: 1uF; C_0805_2012Metric
C7: 10uF; C_0805_2012Metric
D1, D2, D3, D4: D_Small; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2, MX3, MX4: MX-NoLED; MX-1U-NoLED
R1, R2: 22; R_0805_2012Metric
R3, R4: 10k; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C5.1, C7.1, F1.1, R3.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), MX2.1 (COL)
COL1: MX3.1 (COL), MX4.1 (COL)
D+: R2.2, USB1.3 (D+)
D-: R1.2, USB1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1 (GND), Y1.2, Y1.4
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.3
unnamed: C6.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: R1.1, U1.3 (D-)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, SW1.2, U1.13 (~RESET)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D3.1 (K)
ROW1: D2.1 (K), D4.1 (K)
VCC: F1.2, USB1.5 (VBUS)

Board: 2 copper layers, 24 parts (20 on the bottom side), 20 nets, no tracks yet.

## Commit log

2019-07-07 Initialize project
2019-07-07 Add submodules git push
    git add*
2019-07-07 Add footpring libraries
2019-07-07 Commit just in case
2019-07-07 Schematic completed
2019-07-07 Revert "Schematic completed"
    This reverts commit 1cac4397530574a4662a2747fb7876ea94054bb6.
2019-07-08 Schematic fixed
2019-07-08 Fixed schematic again
2019-07-08 Schleep schoon
2019-07-08 Schleep for real
